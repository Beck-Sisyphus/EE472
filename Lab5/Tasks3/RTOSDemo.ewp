# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=; ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: ; ..\Common\ethernet; ..\..\..\..\; ..\Common\drivers\LuminaryMicro; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip; ..; ..\..; ..\..\..; C:\StellarisWare\; C:\StellarisWare\boards\ek-lm3s8962
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a; ..\Common\drivers\LuminaryMicro\IAR\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo files
    ../Common/Minimal/: IntQueue.c
    ./: IntQueueTimer.c main.c timertest.c
    ParTest/: ParTest.c
  group Library files
    ./: consoleKeyboard.c formike128x128x16.c imageCapture.c lab4.h lab4Interrupt.c oledDisplay.c optfft.c optfft.h osram128x64x4.c pirates.c powerSub.c randomInteger.c rit128x96x4.c satelliteComms.c schedule.c solarPanelControl.c thrusterSub.c transport.c vehicleComms.c warningAlarm.c
    ../Common/drivers/LuminaryMicro/IAR/: driverlib.a grlib.a
  group Scheduler files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
  group uIP files
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
